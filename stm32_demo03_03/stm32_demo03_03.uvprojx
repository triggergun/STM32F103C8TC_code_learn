# Keil uVision project stm32_demo03_03.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_demo03 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: E:\stm32f10x_lib\Libraries\STM32F10x_StdPeriph_Driver\inc;E:\stm32f10x_lib\User;E:\stm32f10x_lib\Libraries\CMSIS;E:\stm32f10x_lib\User\led;E:\stm32f10x_lib\User\relay;E:\stm32f10x_lib\User\shake
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    E:/stm32f10x_lib/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    E:/stm32f10x_lib/User/: main.c stm32f10x_it.c
    E:/stm32f10x_lib/User/led/: led.c
    E:/stm32f10x_lib/User/relay/: relay.c
    E:/stm32f10x_lib/User/shake/: shake.c
  group CMSIS
    E:/stm32f10x_lib/Libraries/CMSIS/: system_stm32f10x.c
  group FWLIB
    E:/stm32f10x_lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
